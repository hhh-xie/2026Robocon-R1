# Keil uVision project R1.uvprojx, settings and files
target R1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: R1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Control;../Device;../User;../FreeRTOS/include;../FreeRTOS/portable/RVDS/ARM_CM4F;D:/software/keil-MDK/Pack/ARM/CMSIS-DSP/1.14.2/Include;D:/software/keil-MDK/Pack/ARM/CMSIS-DSP/1.14.2/PrivateInclude
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c fdcan.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group FreeRTOS/portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS/source
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Device
    ../Device/: motor_3508.c motor_dm.c
  group Control
    ../Control/: chassic_motor.c arm_motor.c claw_motor.c lift_motor.c
  group User
    ../User/: freertos_start.c FreeRTOSConfig.h pid.c remote_control.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
